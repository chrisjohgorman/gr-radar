options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: simulator_sync_pulse
    output_language: python
  states: {}

blocks:
- name: num_corr
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: num_skip
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: num_skip
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: radar_estimator_sync_pulse_c_0
  id: radar_estimator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    num_xcorr: int(num_corr)
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_signal_generator_sync_pulse_c_0
  id: radar_signal_generator_sync_pulse_c
  parameters:
    len_key: '"packet_len"'
    packet_len: 2**12
    pulse_amplitude: '0.5'
    pulse_len: (300,50,200)
    pulse_pause: (100,200,50)
  states: {}

connections:
- [blocks_skiphead_0, '0', radar_estimator_sync_pulse_c_0, '0']
- [blocks_throttle2_0, '0', radar_estimator_sync_pulse_c_0, '1']
- [radar_estimator_sync_pulse_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_skiphead_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_tag_debug_0, '0']
- [radar_signal_generator_sync_pulse_c_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0

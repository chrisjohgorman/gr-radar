options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_uhd_sink_source_inbuild
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '5800000000'
  states: {}
- name: freq_res
  id: variable
  parameters:
    value: samp_rate/packet_len
  states: {}
- name: minimum_output_buffer
  id: variable
  parameters:
    value: packet_len*2
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '50000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: minimum_output_buffer
    packet_len: packet_len
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: packet_len
    name: QT GUI Plot
    showports: 'True'
    type: complex
  states: {}
- name: radar_os_cfar_c_0
  id: radar_os_cfar_c
  parameters:
    len_key: '"packet_len"'
    merge_consecutive: 'True'
    minoutbuf: minimum_output_buffer
    mult_threshold: '15'
    rel_threshold: '0.78'
    samp_compare: '15'
    samp_protect: '0'
    samp_rate: samp_rate
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    minoutbuf: minimum_output_buffer
    packet_len: packet_len
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"J1"'
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: gpsdo
    dev_addr: '''addr=192.168.10.6'''
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"J1"'
    center_freq0: center_freq
    clock_rate: '0.0'
    clock_source0: gpsdo
    dev_addr: '"addr=192.168.10.4"'
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', radar_ts_fft_cc_0, '0']
- [radar_os_cfar_c_0, Msg out, radar_print_results_0, Msg in]
- [radar_ts_fft_cc_0, '0', radar_os_cfar_c_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
